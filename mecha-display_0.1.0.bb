# Auto-Generated by cargo-bitbake 0.3.16
#
inherit cargo

# If this is git based prefer versioned ones if they exist
# DEFAULT_PREFERENCE = "-1"

# how to get mecha-display could be as easy as but default to a git checkout:
# SRC_URI += "crate://crates.io/mecha-display/0.1.0"
SRC_URI += "git://github.com/Dhruvesh08/mecha-display.git;protocol=https;nobranch=1;branch=display-v1"
SRCREV = "39186984bbd9419f70ba6878f295d377b14169f0"
S = "${WORKDIR}/git"
CARGO_SRC_DIR = ""
PV:append = ".AUTOINC+39186984bb"

# please note if you have entries that do not begin with crate://
# you must change them to how that package can be fetched
SRC_URI += " \
"



# FIXME: update generateme with the real MD5 of the license file
LIC_FILES_CHKSUM = " \
    "

SUMMARY = "mecha-display"
HOMEPAGE = "https://github.com/Dhruvesh08/mecha-display"
LICENSE = "CLOSED"

# includes this file if it exists but does not fail
# this is useful for anything you may want to override from
# what cargo-bitbake generates.
include mecha-display-${PV}.inc
include mecha-display.inc
